options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: 48e3
  states: {}
- name: rx_freq
  id: variable_qtgui_range
  parameters:
    start: 430e6
    step: 100e3
    stop: 440e6
    value: 433e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: tx_freq
  id: variable_qtgui_range
  parameters:
    start: 430e6
    step: 100e3
    stop: 440e6
    value: 433e6
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    quad_rate: 250e3
  states: {state: disabled}
- name: analog_wfm_rcv_0_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    quad_rate: 250e3
  states: {state: disabled}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: '250000'
    fh: '-1.0'
    max_dev: 75e3
    quad_rate: '500000'
    tau: '75e-6'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {state: disabled}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/bharti/Desktop/BTP_Divyansh_Gopal/GNU Radio/receive2/rec2.iq
    type: complex
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: /home/bharti/Desktop/BTP_Divyansh_Gopal/GNU Radio/receive1/rec1.iq
    type: complex
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/bharti/Downloads/sample-15s.wav
    repeat: 'True'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 100e3
    decim: '8'
    gain: '1'
    interp: '1'
    samp_rate: samp_rate
    type: interp_fir_filter_ccf
    width: 20e3
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 100e3
    decim: '8'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 20e3
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: hackrf=000000000000000066a062dc233e1b9f
    bb_gain0: '40'
    freq0: tx_freq
    gain0: '40'
    if_gain0: '40'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: hackrf=0000000000000000f77c60dc285e9fc3
    bb_gain0: '40'
    freq0: rx_freq
    gain0: '40'
    gain_mode0: 'False'
    if_gain0: '40'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: osmosdr_source_0_0
  id: osmosdr_source
  parameters:
    args: hackrf=RunningFromRAM
    bb_gain0: '40'
    clock_source0: external
    freq0: rx_freq
    gain0: '40'
    gain_mode0: 'False'
    if_gain0: '40'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: tx_freq
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: rx_freq
    fftsize: '1024'
    type: complex
    ymax: '-20'
    ymin: '-80'
  states: {state: disabled}
- name: qtgui_freq_sink_x_1_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: rx_freq
    fftsize: '1024'
    type: complex
    ymax: '-20'
    ymin: '-80'
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '48'
    interp: '250'
    type: fff
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '4'
    type: ccc
  states: {}
- name: rational_resampler_xxx_2
  id: rational_resampler_xxx
  parameters:
    decim: '250'
    interp: '48'
    type: fff
  states: {state: disabled}
- name: rational_resampler_xxx_2_0
  id: rational_resampler_xxx
  parameters:
    decim: '250'
    interp: '48'
    type: fff
  states: {state: disabled}

connections:
- [analog_wfm_rcv_0, '0', rational_resampler_xxx_2, '0']
- [analog_wfm_rcv_0_0, '0', rational_resampler_xxx_2_0, '0']
- [analog_wfm_tx_0, '0', rational_resampler_xxx_1, '0']
- [blocks_wavfile_source_0, '0', rational_resampler_xxx_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [low_pass_filter_0_0, '0', analog_wfm_rcv_0_0, '0']
- [osmosdr_source_0, '0', blocks_file_sink_1, '0']
- [osmosdr_source_0, '0', qtgui_freq_sink_x_1, '0']
- [osmosdr_source_0_0, '0', blocks_file_sink_0, '0']
- [osmosdr_source_0_0, '0', low_pass_filter_0_0, '0']
- [osmosdr_source_0_0, '0', qtgui_freq_sink_x_1_0, '0']
- [rational_resampler_xxx_0, '0', analog_wfm_tx_0, '0']
- [rational_resampler_xxx_1, '0', osmosdr_sink_0, '0']
- [rational_resampler_xxx_1, '0', qtgui_freq_sink_x_0, '0']
- [rational_resampler_xxx_2, '0', audio_sink_0, '0']
- [rational_resampler_xxx_2_0, '0', audio_sink_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
